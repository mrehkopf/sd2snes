# Repository mrehkopf/sd2snes (continued)

## KiCad design pcb/kicad/RevF/sd2snes.kicad_pcb (continued)

Parts:
C201, C202, C203, C204, C205, C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C221, C222, C223, C224, C231, C232, C233, C234: 100n; SM0805_FIXEDMASK
P113: CONN_1
U201: XC3S400-PQ208; PQFP208

Connections:
+1.2V: C221.1, C222.1, C223.1, C224.1, U201.70 (VCCINT), U201.88 (VCCINT), U201.174 (VCCINT), U201.192 (VCCINT); also elsewhere on the board
+2.5V: C210.1, C211.1, C212.1, C213.1, C214.1, C215.1, U201.17 (VCCAUX), U201.38 (VCCAUX), U201.69 (VCCAUX), U201.89 (VCCAUX), U201.121 (VCCAUX), U201.142 (VCCAUX), U201.173 (VCCAUX), U201.193 (VCCAUX); also elsewhere on the board
+3.3V: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C207.1, C208.1, C209.1, C231.1, C232.1, C233.1, C234.1, U201.6 (VCCO_7), U201.23 (VCCO_7), U201.32 (VCCO_6), U201.49 (VCCO_6), U201.60 (VCCO_5), U201.73 (VCCO_5), U201.84 (VCCO_4), U201.98 (VCCO_4), U201.110 (VCCO_3), U201.127 (VCCO_3), U201.136 (VCCO_2), U201.153 (VCCO_2), U201.164 (VCCO_1), U201.177 (VCCO_1), U201.188 (VCCO_0), U201.201 (VCCO_0); also elsewhere on the board
CCLK: U201.104 (CCLK); also elsewhere on the board
DAC_LRCK: U201.77 (IO_L32N_5/GCLK3); also elsewhere on the board
DAC_MCLK: U201.76 (IO_L32P_5/GCLK2); also elsewhere on the board
DAC_SDIN: U201.78 (IO/VREF_5); also elsewhere on the board
DATABUS_/OE: U201.109 (IO_L17N_3); also elsewhere on the board
DATABUS_DIR: U201.111 (IO_L19P_3); also elsewhere on the board
DIN+MCU_/OVR: U201.92 (IO_L27N_4/DIN/D0); also elsewhere on the board
DONE: U201.103 (DONE); also elsewhere on the board
FPGA_CLK: U201.80 (IO_L32N_4/GCLK1); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C221.2, C222.2, C223.2, C224.2, C231.2, C232.2, C233.2, C234.2, U201.1 (GND), U201.8 (GND), U201.14 (GND), U201.25 (GND), U201.30 (GND), U201.41 (GND), U201.47 (GND), U201.53 (GND), U201.59 (GND), U201.66 (GND), U201.75 (GND), U201.82 (GND), U201.91 (GND), U201.99 (GND), U201.105 (GND), U201.112 (GND), U201.118 (GND), U201.129 (GND), U201.134 (GND), U201.145 (GND), U201.151 (GND), U201.157 (GND), U201.163 (GND), U201.170 (GND), U201.179 (GND), U201.186 (GND), U201.195 (GND), U201.202 (GND), U201.206 (HSWAP_EN); also elsewhere on the board
INIT_B+MCU_IRQ: U201.83 (IO_L31N_4/INIT_B); also elsewhere on the board
MCU_SPI_MISO: U201.72 (IO_L31P_5/D5); also elsewhere on the board
MCU_SPI_MOSI: U201.74 (IO_L31N_5/D4); also elsewhere on the board
MCU_SPI_SCK: U201.71 (IO); also elsewhere on the board
MCU_SPI_SS: U201.68 (IO_L28N_5/D6); also elsewhere on the board
unnamed: P113.1, U201.113 (IO_L19N_3)
PROG_B: U201.207 (PROG_B); also elsewhere on the board
RAM_/OE: U201.36 (IO_L23P_6); also elsewhere on the board
RAM_/WE: U201.50 (IO/VREF_6); also elsewhere on the board
RAM_A0: U201.28 (IO_L40P_6/VREF_6); also elsewhere on the board
RAM_A1: U201.31 (IO_L39P_6); also elsewhere on the board
RAM_A2: U201.33 (IO_L39N_6); also elsewhere on the board
RAM_A3: U201.35 (IO_L24N_6/VREF_6); also elsewhere on the board
RAM_A4: U201.37 (IO_L23N_6); also elsewhere on the board
RAM_A5: U201.40 (IO_L22N_6); also elsewhere on the board
RAM_A6: U201.43 (IO_L21N_6); also elsewhere on the board
RAM_A7: U201.45 (IO_L20N_6); also elsewhere on the board
RAM_A8: U201.44 (IO_L20P_6); also elsewhere on the board
RAM_A9: U201.42 (IO_L21P_6); also elsewhere on the board
RAM_A10: U201.34 (IO_L24P_6); also elsewhere on the board
RAM_A11: U201.39 (IO_L22P_6); also elsewhere on the board
RAM_A12: U201.48 (IO_L19N_6); also elsewhere on the board
RAM_A13: U201.46 (IO_L19P_6); also elsewhere on the board
RAM_A14: U201.51 (IO_L01P_6/VRN_6); also elsewhere on the board
RAM_A15: U201.58 (IO_L01N_5/RDWR_B); also elsewhere on the board
RAM_A16: U201.57 (IO_L01P_5/CS_B); also elsewhere on the board
RAM_A17: U201.61 (IO_L10P_5/VRN_5); also elsewhere on the board
RAM_A18: U201.52 (IO_L01N_6/VRP_6); also elsewhere on the board
RAM_DQ0: U201.26 (IO_L40P_7); also elsewhere on the board
RAM_DQ1: U201.22 (IO_L39P_7); also elsewhere on the board
RAM_DQ2: U201.20 (IO_L24P_7); also elsewhere on the board
RAM_DQ3: U201.19 (IO_L23N_7); also elsewhere on the board
RAM_DQ4: U201.21 (IO_L24N_7); also elsewhere on the board
RAM_DQ5: U201.24 (IO_L39N_7); also elsewhere on the board
RAM_DQ6: U201.27 (IO_L40N_7/VREF_7); also elsewhere on the board
RAM_DQ7: U201.29 (IO_L40N_6); also elsewhere on the board
ROM_/CE: U201.172 (IO_L28N_1); also elsewhere on the board
ROM_/LB: U201.156 (IO_L01N_2/VRP_2); also elsewhere on the board
ROM_/OE: U201.162 (IO_L01N_1/VRP_1); also elsewhere on the board
ROM_/UB: U201.161 (IO_L01P_1/VRN_1); also elsewhere on the board
ROM_/WE: U201.190 (IO_L30P_0); also elsewhere on the board
ROM_A0: U201.166 (IO_L10N_1/VREF_1); also elsewhere on the board
ROM_A1: U201.168 (IO_L27P_1); also elsewhere on the board
ROM_A2: U201.171 (IO_L28P_1); also elsewhere on the board
ROM_A3: U201.165 (IO_L10P_1); also elsewhere on the board
ROM_A4: U201.169 (IO_L27N_1); also elsewhere on the board
ROM_A5: U201.18 (IO_L23P_7); also elsewhere on the board
ROM_A6: U201.175 (IO); also elsewhere on the board
ROM_A7: U201.167 (IO); also elsewhere on the board
ROM_A8: U201.205 (IO/VREF_0); also elsewhere on the board
ROM_A9: U201.204 (IO_L01N_0/VRP_0); also elsewhere on the board
ROM_A10: U201.197 (IO); also elsewhere on the board
ROM_A11: U201.196 (IO_L27N_0); also elsewhere on the board
ROM_A12: U201.2 (IO_L01P_7/VRN_7); also elsewhere on the board
ROM_A13: U201.194 (IO_L27P_0); also elsewhere on the board
ROM_A14: U201.200 (IO/VREF_0); also elsewhere on the board
ROM_A15: U201.184 (IO_L32N_0/GCLK7); also elsewhere on the board
ROM_A16: U201.199 (IO_L25N_0); also elsewhere on the board
ROM_A17: U201.11 (IO_L20N_7); also elsewhere on the board
ROM_A18: U201.3 (IO_L01N_7/VRP_7); also elsewhere on the board
ROM_A19: U201.4 (IO_L16P_7/VREF_7); also elsewhere on the board
ROM_A20: U201.191 (IO_L30N_0); also elsewhere on the board
ROM_A21: U201.203 (IO_L01P_0/VRN_0); also elsewhere on the board
ROM_A22: U201.198 (IO_L25P_0); also elsewhere on the board
ROM_DQ0: U201.176 (IO_L31P_1); also elsewhere on the board
ROM_DQ1: U201.178 (IO_L31N_1/VREF_1); also elsewhere on the board
ROM_DQ2: U201.181 (IO_L32N_1GCLK5); also elsewhere on the board
ROM_DQ3: U201.182 (IO); also elsewhere on the board
ROM_DQ4: U201.183 (IO_L32P_0/GCLK6); also elsewhere on the board
ROM_DQ5: U201.187 (IO_L31N_0); also elsewhere on the board
ROM_DQ6: U201.185 (IO_L31P_0/VREF_0); also elsewhere on the board
ROM_DQ7: U201.189 (IO); also elsewhere on the board
ROM_DQ8: U201.16 (IO_L22N_7); also elsewhere on the board
ROM_DQ9: U201.13 (IO_L21N_7); also elsewhere on the board
ROM_DQ10: U201.15 (IO_L22P_7); also elsewhere on the board
ROM_DQ11: U201.12 (IO_L21P_7); also elsewhere on the board
ROM_DQ12: U201.10 (IO_L20P_7); also elsewhere on the board
ROM_DQ13: U201.7 (IO_L19P_7); also elsewhere on the board
ROM_DQ14: U201.9 (IO_L19N_7/VREF_7); also elsewhere on the board
ROM_DQ15: U201.5 (IO_L16N_7); also elsewhere on the board
SD_CLK: U201.64 (IO_L27P_5); also elsewhere on the board
SD_CMD: U201.67 (IO_L28P_5/D7); also elsewhere on the board
SD_DAT0: U201.65 (IO_L27N_5/VREF_5); also elsewhere on the board
SD_DAT1: U201.79 (IO_L32P_4/GCLK0); also elsewhere on the board
SD_DAT2: U201.62 (IO_L10N_5/VRP_5); also elsewhere on the board
SD_DAT3: U201.63 (IO); also elsewhere on the board
SNES_/PARD: U201.149 (IO_L20N_2); also elsewhere on the board
SNES_/PAWR: U201.150 (IO_L19P_2); also elsewhere on the board
SNES_/RD: U201.115 (IO_L20N_3); also elsewhere on the board
SNES_/ROMSEL: U201.116 (IO_L21P_3); also elsewhere on the board
SNES_/WR: U201.94 (IO_L25P_4); also elsewhere on the board
SNES_A0: U201.119 (IO_L22P_3); also elsewhere on the board
SNES_A1: U201.122 (IO_L23P_3/VREF_3); also elsewhere on the board
SNES_A2: U201.124 (IO_L24P_3); also elsewhere on the board
SNES_A3: U201.126 (IO_L39P_3); also elsewhere on the board
SNES_A4: U201.130 (IO_L40P_3); also elsewhere on the board
SNES_A5: U201.132 (IO_L40P_2/VREF_2); also elsewhere on the board
SNES_A6: U201.135 (IO_L39P_2); also elsewhere on the board
SNES_A7: U201.138 (IO_L24P_2); also elsewhere on the board
SNES_A8: U201.140 (IO_L23P_2); also elsewhere on the board
SNES_A9: U201.143 (IO_L22P_2); also elsewhere on the board
SNES_A10: U201.146 (IO_L21P_2); also elsewhere on the board
SNES_A11: U201.148 (IO_L20P_2); also elsewhere on the board
SNES_A12: U201.147 (IO-L21N_2); also elsewhere on the board
SNES_A13: U201.144 (IO_L22N_2); also elsewhere on the board
SNES_A14: U201.141 (IO_L23N_2/VREF_2); also elsewhere on the board
SNES_A15: U201.139 (IO_L24N_2); also elsewhere on the board
SNES_A16: U201.137 (IO_L39N_2); also elsewhere on the board
SNES_A17: U201.133 (IO_L40N_2); also elsewhere on the board
SNES_A18: U201.131 (IO_L40N_3/VREF_3); also elsewhere on the board
SNES_A19: U201.128 (IO_L39N_3); also elsewhere on the board
SNES_A20: U201.125 (IO_L24N_3); also elsewhere on the board
SNES_A21: U201.123 (IO_L23N_3); also elsewhere on the board
SNES_A22: U201.120 (IO_L22N_3); also elsewhere on the board
SNES_A23: U201.117 (IO_L21N_3); also elsewhere on the board
SNES_CPU_CLK: U201.95 (IO_L25N_4); also elsewhere on the board
SNES_D0: U201.107 (IO_L01N_3/VRP_3); also elsewhere on the board
SNES_D1: U201.102 (IO/VREF_4); also elsewhere on the board
SNES_D2: U201.100 (IO_L01P_4/VRN_4); also elsewhere on the board
SNES_D3: U201.96 (IO/VREF_4); also elsewhere on the board
SNES_D4: U201.108 (IO_L17P_3/VREF_3); also elsewhere on the board
SNES_D5: U201.106 (IO_L01P_3/VRN_3); also elsewhere on the board
SNES_D6: U201.101 (IO_L01N_4/VRP_4); also elsewhere on the board
SNES_D7: U201.97 (IO); also elsewhere on the board
SNES_IRQ_EN: U201.114 (IO_L20P_3); also elsewhere on the board
SNES_PA0: U201.90 (IO_L27P_4/D1); also elsewhere on the board
SNES_PA1: U201.93 (IO); also elsewhere on the board
SNES_PA2: U201.86 (IO_L30P_4/D3); also elsewhere on the board
SNES_PA3: U201.87 (IO_L30N_4/D2); also elsewhere on the board
SNES_PA4: U201.81 (IO_L31P_4/DOUT/BUSY); also elsewhere on the board
SNES_PA5: U201.85 (IO/VREF_4); also elsewhere on the board
SNES_PA6: U201.152 (IO_L19N_2); also elsewhere on the board
SNES_PA7: U201.154 (IO/VREF_2); also elsewhere on the board
SNES_REFRESH: U201.155 (IO_L01P_2/VRN_2); also elsewhere on the board
SNES_SYS_CLK: U201.180 (IO_L32P_1/GCLK4); also elsewhere on the board

Notes on the sheet:
FPGA
SNES A+B bus
70ns PSRAM bus
45ns SRAM bus
SD bus; shared with MCU
SPI (MCU interface)
DAC
JTAG

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
Board: 2 copper layers, 101.5 x 83.0 mm, 153 parts (0 on the bottom side), 326 nets.

## Code that names these connections

File mk1-src/config.h:

/* sd2snes - SD card based universal cartridge for the SNES
   Copyright (C) 2009-2010 Maximilian Rehkopf <otakon@gmx.net>
   This file was adapted from sd2iec, written by Ingo Korb.
   Original copyright header follows:
*/
/*
   sd2iec - SD/MMC to Commodore serial bus interface/controller
   Copyright (C) 2007-2009  Ingo Korb <ingo@akana.de>

   Inspiration and low-level SD/MMC access based on code from MMC2IEC
     by Lars Pontoppidan et al., see sdcard.c|h and config.h.

   FAT filesystem access based on code from ChaN and Jim Brain, see ff.c|h.

   This program is free software; you can redistribute it and/or modify
   it under the terms of the GNU General Public License as published by
   the Free Software Foundation; version 2 of the License only.

   This program is distributed in the hope that it will be useful,
   but WITHOUT ANY WARRANTY; without even the implied warranty of
   MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
   GNU General Public License for more details.

   You should have received a copy of the GNU General Public License
   along with this program; if not, write to the Free Software
   Foundation, Inc., 59 Temple Place, Suite 330, Boston, MA  02111-1307  USA

   config.h: User-configurable options to simplify hardware changes and/or
             reduce the code/ram requirements of the code.

   Based on MMC2IEC, original copyright header follows:

//
// Title        : MMC2IEC - Configuration
// Author       : Lars Pontoppidan
// Date         : Jan. 2007
// Version      : 0.7
// Target MCU   : AtMega32(L) at 8 MHz
//
//
// DISCLAIMER:
// The author is in no way responsible for any problems or damage caused by
// using this code. Use at your own risk.
//
// LICENSE:
// This code is distributed under the GNU Public License
// which can be found at http://www.gnu.org/licenses/gpl.txt
//

*/

#ifndef CONFIG_H
#define CONFIG_H

#include "autoconf.h"

#  define HW_NAME "SD2IEC"
#  define HAVE_SD
#  define SDCARD_DETECT         (!(PIND & _BV(PD2)))
#  define SDCARD_DETECT_SETUP() do { DDRD &= ~_BV(PD2); PORTD |= _BV(PD2); } while(0)
#  if defined __AVR_ATmega32__
#    define SD_CHANGE_SETUP()   do { MCUCR |= _BV(ISC00); GICR |= _BV(INT0); } while(0)
#  elif defined __AVR_ATmega644__ || defined __AVR_ATmega644P__
#    define SD_CHANGE_SETUP()   do { EICRA |= _BV(ISC00); EIMSK |= _BV(INT0); } while(0)
#  else
#    error Unknown chip!
#  endif
#  define SD_CHANGE_VECT        INT0_vect
#  define SDCARD_WP  			(PINA & _BV(PA0))
#  define SDCARD_WP_SETUP()     do { DDRA &= ~ _BV(PA0); PORTA |= _BV(PA0); } while(0)
#  define SD_CHANGE_ICR         MCUCR
#  define SD_SUPPLY_VOLTAGE     (1L<<21)
#  define DEVICE_SELECT         (8+!(PINA & _BV(PA2))+2*!(PINA & _BV(PA3)))
#  define DEVICE_SELECT_SETUP() do {        \
             DDRA  &= ~(_BV(PA2)|_BV(PA3)); \
             PORTA |=   _BV(PA2)|_BV(PA3);  \
          } while (0)
#  define BUSY_LED_SETDDR()     DDRA  |= _BV(PA0)
#  define BUSY_LED_ON()         PORTA &= ~_BV(PA0)
#  define BUSY_LED_OFF()        PORTA |= _BV(PA0)
#  define DIRTY_LED_SETDDR()    DDRA  |= _BV(PA1)
#  define DIRTY_LED_ON()        PORTA &= ~_BV(PA1)
#  define DIRTY_LED_OFF()       PORTA |= _BV(PA1)
#  define DIRTY_LED_PORT        PORTA
#  define DIRTY_LED_BIT()       _BV(PA1)
#  define AUX_LED_SETDDR()      do {} while (0)
#  define AUX_LED_ON()          do {} while (0)
#  define AUX_LED_OFF()         do {} while (0)
#  define BUTTON_PIN            PINA
#  define BUTTON_PORT           PORTA
#  define BUTTON_DDR            DDRA
#  define BUTTON_MASK           (_BV(PA4)|_BV(PA5))
#  define BUTTON_NEXT           _BV(PA4)
#  define BUTTON_PREV           _BV(PA5)

/* An interrupt for detecting card changes implies hotplugging capability */
#if defined(SD_CHANGE_VECT) || defined (CF_CHANGE_VECT)
#  define HAVE_HOTPLUG
#endif

/* Generate dummy functions for the BUSY LED if required */
#ifdef SINGLE_LED
#  define BUSY_LED_SETDDR() do {} while(0)
#  define BUSY_LED_ON()     do {} while(0)
#  define BUSY_LED_OFF()    do {} while(0)
#endif

/* Create some temporary symbols so we can calculate the number of */
/* enabled storage devices.                                        */
#ifdef HAVE_SD
#  define TMP_SD 1
#endif

/* Remove the temporary symbols */
#undef TMP_SD

#endif

File verilog/sd2snes_test/main.ucf (part):

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
NET "SNES_IRQ" LOC = P114;
NET "SNES_READ_IN" LOC = P115;
NET "SNES_REFRESH" LOC = P155;
NET "SNES_WRITE_IN" LOC = P94;

NET "SNES_PA_IN[0]" IOSTANDARD = LVCMOS33;
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NET "SPI_SS" DRIVE = 8;

NET "DAC_LRCK" LOC = P77;

NET "DAC_LRCK" IOSTANDARD = LVCMOS33;
NET "DAC_LRCK" DRIVE = 8;

NET "DAC_MCLK" LOC = P76;

NET "DAC_MCLK" IOSTANDARD = LVCMOS33;
NET "DAC_MCLK" DRIVE = 8;

NET "DAC_SDOUT" LOC = P78;
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
# PlanAhead Generated physical constraints 

NET "SD_CLK" LOC = P64;
NET "SD_CMD" LOC = P67;
NET "SD_DAT[0]" LOC = P65;
NET "SD_DAT[1]" LOC = P79;
NET "SD_DAT[2]" LOC = P62;
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
## Commit log (part)

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2021-07-27 Generate dependency files for SNES menu build
2021-07-27 DSPx: get up to date with base core
    (relocatable save ram area, unlockable banks E0-FF, USB EXE hook...)
2021-07-27 Increase reset loop timeout
    (increase chance of finding a good CPU/PPU phase relation)
2021-07-27 Add clean targets to global and utils makefiles
2021-07-27 SGB: update supplementary file CRCs, use canonical CRC32
2021-07-27 FPGA build: add header files to prerequisites
2021-07-27 FPGA build: fix hardcoded paths
2021-07-27 SGB: add dedicated MSU1 build for sd2snes Mk.2
2021-07-27 global Makefile: package yml and README files
2021-07-27 Global Makefile: use proper subdir make for build+clean
2021-07-28 FPGA: update auto region patch state machine for all cores
2021-07-28 Enable PPU-CPU clock phase alignment by default
2021-07-28 Rename FURiOUS Savestates readme
2021-07-28 FPGA: fix ROM address detection to exclude WRAM
    (simply use /ROMSEL from SNES instead of manual decoding)
2021-07-28 Add entries to savestate_fixes.yml
2021-07-28 Add tribute to Near
2021-07-29 [FPGA/GSU] correct NMI/IRQ vector injection cycle count
2021-07-30 [FPGA/test] update initial values and edge detection from base core
2021-11-15 Fixed SD2SNES classic 3-4 controller state reset bug caused by unexpected Xilinx compiler behavior. Explicit default was added as NOP.
2022-11-24 Added preliminary link support for SD2SNES MK3 (Pro). This requires wiring up the 3-wire debug bus, {PM6,PN5,PT5} and a GND, to a link port terminal. Level shifting is ideal, but it functions for tes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
    //`define SGB_SERIAL_OVER_DBG
    SC - SerialClock
    SI - SerialIn (wrt SD2SNES)
    SO - SerialOut (wrt SD2SNES)
    SC - PM6
    SO - PN5
2022-11-27 Fixed ringing/cutting out of square wave channels 1 and 2 by removing NRx3 write duty position updates. This change was originally to fix SML end of stage coin ringing, but NRx3 isn't necessary. Many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
2022-12-10 Fixed serial connection to be more reliable for first connect.
2022-12-16 Fix README link
    Fix the README link with the correct URL.
2023-02-03 Configurable header size
    necessary to support MCUs with varying VTOR granularity
2023-02-03 Build: Generate ELF output with baked-in firmware header
    Necessary for debug probes used with gdb, e.g. Black Magic Probe
2023-02-03 Prepare support for multiple platforms
    * Move platform specific code to subdirectory
    * Abstract GPIO functions using macros
    * Remove platform specific includes
2023-02-03 Add missing .fwhdr sections
2023-02-03 USB: increase maximum control endpoint packet size
2023-02-03 MSU1: force a single SRAM check on game boot
2023-02-03 FPGA: fix occasional crash on save/load state
    Savestate hook requires re-entry from NMI/IRQ, but lack of detected button
    presses can preempt that and jump back to the game instead, corrupting
    the stack and disrupting savestate hook execution flow.
    A force_entry flag is added that is set when the FPGA enables the branch
    to the savestate handler, and does not disable it before hook mapping
    is disabled by the unlock_disable register ($2BFD).
2023-02-03 MSU1: gather some seek statistics
2023-02-03 USB: add some debug logging
2023-02-03 FPGA: General update of generated files
2023-02-03 SNES: add some comments to savestate handler
2023-02-03 Update savestates YAML files
    - Correct Checksums for DKC1, reported by limefiasco
    - Add Super Morph (E)
2023-02-09 Add missing linker script
2023-02-11 Added more game audio patches for savestates. (#193)
2023-02-12 Remove obsolete configuration entries
2023-02-16 CLI: add mv command
2023-02-16 Fix for SGB controller multitap on SD2SNES mk2 (classic) (#168)
2023-02-17 Fix: wrong video mode in SuperCIC pair mode
    In pair mode, CIC data lines are supposed to be outputs from the POV of the MCU.
    During operation they could be switched back to inputs by the SysTick handler,
    resetting the video mode/region back to NTSC regardless of settings.
2023-02-18 Build: Explicitly specify gawk instead of awk
    gawk features are used in the conf2h.awk. Fixes build on macos
2023-02-19 Fix firmware header magic for Mk.3 builds
    Copy&paste error overwrote this with the STM32 magic (Mk.3 Rev.D)
2023-02-20 Added more savestate patches. (#200)
2023-02-23 Fix boot ROM source for recent snescom assembler versions
2023-02-23 Add capability to print FATFS error strings
2023-02-23 Show hardware maker, model and revision on early boot screen
2023-02-23 Fix centering in hardware string
2023-03-02 Fix bootloader programming
2023-03-07 Build: Add option for extra OpenOCD script search path
    - Eliminate duplicate OpenOCD scripts
    - enable bootloader to build again
2023-03-24 Workaround S-CPU B DMA silicon bug
    The SNES's CPU revision B occasionally does not carry out DMA transfers when a HDMA channel is configured to use $2100 as a B-Bus target, i.e. $00 must not be written to any DMA channel's B-Bus addre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
    The fix sets $21ff (unmapped) as a target address instead and configures the DMA channel to write two registers, thereby wrapping around to $2100 on the second write.
2023-03-24 Workaround S-CPU A DMA silicon bug
    The SNES's CPU revision A occasionally does not carry out DMA transfers when a HDMA channel is configured to use $2100 as a B-Bus target, i.e. $00 must not be written to any DMA channel's B-Bus addre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
    The fix sets $21ff (unmapped) as a target address instead and configures the DMA channel to write two registers, thereby wrapping around to $2100 on the second write.
2023-03-30 update generated files
2023-03-30 fix MSU1 address increment for rest of the FPGA cores
2023-04-07 Correct comments in MSU1 video player code
    S-CPU B -> S-CPU A
2023-04-27 Fixed savestate slot bug where a load didn't wait for a slot change to complete. Added Chrono Trigger savestate audio fix.
2023-06-21 Add config toggles for Autosave & MSU1 Autosave
    Since MSU1 auto saving may lead to undesired delays on track changes for quirky hacks, add a config option to turn it off.
    In the process, a global autosave disable option is also introduced.
    MSU1 autosave is automatically disabled when global autosave is disabled.
2023-06-21 MSU1: speed up bulk PCM file scanning by some games
    Some games, notably ALTTP Randomizer, perform a full scan of all PCM tracks on startup. After adding MSU1 SRAM checks, this led to a full SRAM check per track scanned (because it was considered a saf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
    SRAM check is now relaxed to at most once per second on track change; startup time is reduced to about 600ms.
2023-08-13 Fixed SGB RTC by adding dummy write to account for data buffer.
2023-08-19 Reword skin files as theme files Everyone seems to use the word "themes" already so let's go with that
2023-08-19 Prepare menu for theme swapping
2023-08-19 OpenOCD: Use soft instead of hard reset
    LPC17xx likes to lock up on nSRST reset, requiring a power cycle which is inconvenient for development
2023-08-21 SuperFX: Revert to previous bus sampling timing
    This seems to have caused random access glitches for the GSU core.
2024-08-17 MSU1 video player: compensate for A/V desync
    When the MSU1 audio sample rate was locked at exactly 44100Hz in 829953b, some A/V desync was introduced in videos played by the example video player.
    Audio sample rate had previously been set to a slightly higher rate to match the slightly higher vertical refresh rate of the SNES.
    This commit repeats a video frame occasionally, based on a phase accumulator, to keep video playback from running ahead of audio.
2024-08-19 Correct error logging for console `mv` command
    Change logging from "oldname, newname" to "oldname", "newname"
2025-06-22 Improve Xilinx legacy tool compatibility
2025-06-22 Close directory handle after scanning in scan_dir
2025-06-22 Fix detection of S-DD1 ROMs bigger than 48Mbits
2025-06-24 S-DD1: support "mixed mapper" SRAM mapping
    Both "HiROM" and "LoROM" style mapping are supported by S-DD1.
    Also remove redundant code and connections for address decoder.
2025-08-06 Make FPGA feature flags / FW config available to USB interface
    * Expand current_features to 16 bits and move to main
    * Expose current_features via USB INFO opcode
    * Add `CFG` space to USB to directly access YAML config values
2025-08-07 SD error wording
2026-03-02 Split sram work and added vget support
2026-03-02 fixed compile issue
2026-03-16 feat: Add autoboot
2026-03-21 Makefile: remove some extra blank lines
2026-03-27 refactor: rename bright_limit to menu_brightness
    Hopefully clarify that it's not supposed to be the same as CFG_BRIGHTNESS_LIMIT but the runtime standard brightness for the menu (as opposed to the dimmed brightness when screensaver is active)
2026-03-27 fix: amend pad state when clearing autoboot
    When coming in from a cleared pad state, when the user holds START to disable autoboot the first occurence of read_pad *afterwards* will immediately bring up the Recent Games list because the pad han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
    Therefore set the START button bit in the previous controller state (pad1mem) to avoid triggering.
    This becomes unnecessary if autoboot_start_poll uses read_pad instead of polling the pad register manually.
2026-03-30 Autoboot: Abridge and correct comments
2026-04-07 fix: Region Patch ($213F) skip if mapper 5
2026-04-07 feat: Sufami Turbo add Slot B
2026-04-07 chore: remove duplicate defines
2026-04-07 feat: Added IPS patching and menu
2026-04-07 revert: restore comment in filetypes.c
2026-04-12 fix: Correcting region. Now defaulting to 60Hz.
2026-04-14 revert: Region Patch ($213F) skip if mapper 5; Not required with correct region
2026-04-16 chore: improve/correct comments
2026-04-24 Added missing code
2026-04-27 Remove duplicate code/definitions
2026-04-27 Explicitly write out long branch
2026-04-27 fix: SA-1 bus sampling
    Do not yield bus to MCU too late in cycle; this was a byproduct of too late ROMSEL sampling leading to setup violations for SNES CPU reads
2026-04-27 FPGA compilation: allow timing violations for a quick build
    Use by calling `make [...] IGNORE_TIMING=1`
2026-05-08 Added put failsafe
2026-05-14 Bump menu version number
    (inconsequential but makes Ultra16 and the makeshift "theme editor" show the correct detected version)
2026-05-16 Autoboot: speed up autobooting
    Holding START during boot doesn't really need a 1s time frame
2026-05-16 menu: Remove weird rudiments
2026-05-17 Menu: Context Menu for Recent Games list
    Add a context menu to the Recent Games list with the following functions:
    - Add to favorites
    - Set as autoboot
    - Remove from recent games
2026-05-17 Bump version number to 1.11.2
2026-05-18 Update BSX page file data to reflect recent changes
2026-06-19 CIC: banksel macro was only 1 instruction on 12F629
2026-06-19 CIC: Fix lock-resync timing
    Adjust the PIC CIC lock routine timing, update HEX file
    Fixes various stuff with CIC dependent cartridges not working on OSCR, Ultra16 et al.
2026-06-21 feat: BS Memory Pack on SA-1 carts
    Pack read through the SuperMMC, flash FSM mirrors the base core (erase by $D0 address). Write stays synchronous since SA-1 slotted carts are read-only.

Notices in the files:
pcb/kicad/RevF/sd2snes.kicad_pcb:
©2009 - 2014 ikari_01
